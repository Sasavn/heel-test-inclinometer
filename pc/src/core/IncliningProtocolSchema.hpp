#pragma once
// Implementations live here to keep the model header-only, as other core
// schemas do.
#include "IncliningProtocolData.hpp"
#include <cmath>
#include <iomanip>
#include <sstream>
#include <stdexcept>

namespace heel::formal
{
inline const std::vector<std::string> &SectionNames()
{
    static const std::vector<std::string> names = {"Титульный лист",
                                                   "1. ОБЩИЕ ПОЛОЖЕНИЯ",
                                                   "2. ИСХОДНЫЕ ДАННЫЕ И КОНСТРУКЦИЯ КОРПУСА СУДНА",
                                                   "3. ОРГАНИЗАЦИЯ И УСЛОВИЯ КРЕНОВАНИЯ",
                                                   "4. ПОДГОТОВКА К КРЕНОВАНИЮ",
                                                   "5. КРЕНОВАНИЕ",
                                                   "6. ОБРАБОТКА РЕЗУЛЬТАТОВ КРЕНОВАНИЯ",
                                                   "7. ОЦЕНКА КАЧЕСТВА КРЕНОВАНИЯ",
                                                   "8. ЗАКЛЮЧЕНИЕ",
                                                   "9. ДОКУМЕНТАЦИЯ",
                                                   "ПРИЛОЖЕНИЕ А",
                                                   "ПРИЛОЖЕНИЕ Б",
                                                   "ПРИЛОЖЕНИЕ В",
                                                   "ПРИЛОЖЕНИЕ Г",
                                                   "ПРИЛОЖЕНИЕ Д",
                                                   "ПРИЛОЖЕНИЕ Е",
                                                   "ПРИЛОЖЕНИЕ Ж"};
    return names;
}

inline const std::vector<FieldSpec> &FieldSpecs()
{
    static const std::vector<FieldSpec> v = {
        {"document_number", "Обозначение документа", 0},
        {"organization", "Организация", 0},
        {"vessel_name", "Наименование судна", 0},
        {"project_number", "Проект судна", 0},
        {"document_date", "Дата составления", 0},
        {"document_place", "Место составления", 0},
        {"document_letter", "Литера документа", 0},
        {"organization_website", "Сайт организации (если указан)", 0},
        {"developer", "Разработал (ФИО, должность)", 0},
        {"checker", "Проверил (ФИО, должность)", 0},
        {"developer_date", "Дата строки Разработал", 0},
        {"checker_date", "Дата строки Проверил", 0},
        {"bureau_head", "Начальник бюро", 0},
        {"norm_controller", "Нормоконтроль", 0},
        {"bureau_head_date", "Дата строки Начальник бюро", 0},
        {"norm_controller_date", "Дата строки Нормоконтроль", 0},
        {"approver", "Утвердил (ФИО, должность)", 0},
        {"revision", "Изменение", 0},
        {"approver_date", "Дата строки Утвердил", 0},
        {"purpose", "Цель опыта и основания определения характеристик порожнем", 1},
        {"rules_basis", "Применяемые правила и редакция (ввод ответственного)", 1},
        {"instruction", "Инструкция по проведению опыта (обозначение)", 1},
        {"instruction_approval", "Сведения об одобрении инструкции, документ и дата (если имеются)", 1},
        {"vessel_type", "Тип и назначение судна", 2},
        {"build_year_place", "Год и место постройки", 2},
        {"vessel_class", "Класс судна (по документу)", 2},
        {"register_number", "Регистровый номер", 2},
        {"length_overall_m", "Длина наибольшая, м", 2},
        {"length_reference_m", "Длина расчётная L, м", 2},
        {"length_waterline_m", "Длина по КВЛ, м", 2},
        {"breadth_overall_m", "Ширина наибольшая, м", 2},
        {"breadth_waterline_m", "Ширина по КВЛ B, м", 2},
        {"depth_m", "Высота борта H, м", 2},
        {"hull_construction", "Конструкция корпуса", 2},
        {"coordinate_system", "Начало координат и знаки X/Y/Z (X от миделя; Y к ПрБ; Z вверх)", 2},
        {"experiment_place", "Место проведения опыта", 3},
        {"experiment_date", "Дата опыта", 3},
        {"start_time", "Время начала опыта", 3},
        {"end_time", "Время окончания опыта", 3},
        {"time_zone", "Часовой пояс времени опыта", 3},
        {"current_speed_ms", "Скорость течения, м/с", 3},
        {"wind_speed_ms", "Скорость ветра, м/с", 3},
        {"air_temperature_c", "Температура воздуха, °C", 3},
        {"underkeel_clearance_m", "Глубина под килем, м", 3},
        {"water_density_tm3", "Плотность воды ρ, т/м³", 3},
        {"waves", "Волнение", 3},
        {"ice", "Ледовая обстановка", 3},
        {"commission_leader", "Руководитель опыта", 3},
        {"commission_members", "Члены комиссии", 3},
        {"customer_representative", "Представитель заказчика", 3},
        {"surveyor", "Присутствовавший инспектор (если был)", 3},
        {"preparation", "Подготовка судна по инструкции (фактическое состояние)", 4},
        {"mooring", "Швартовка и слабина швартовов", 4},
        {"foreign_objects", "Посторонние предметы и мусор", 4},
        {"icing", "Обледенение корпуса", 4},
        {"machinery", "Состояние работающих механизмов", 4},
        {"load_condition", "Состояние нагрузки при замере осадок и креновании", 4},
        {"draft_method", "Способ замера и приведения осадок к теоретическим перпендикулярам", 4},
        {"draft_error_m", "Погрешность измерения осадок ±ΔT, м", 4},
        {"draft_forward_m", "Осадка носом от ОП на теоретическом перпендикуляре, м", 4},
        {"draft_aft_m", "Осадка кормой от ОП на теоретическом перпендикуляре, м", 4},
        {"draft_mean_m", "Расчётная средняя осадка, м", 4},
        {"draft_port_m", "Осадка на миделе ЛБ, м", 4},
        {"draft_starboard_m", "Осадка на миделе ПрБ, м", 4},
        {"draft_transverse_span_m", "Ширина между точками замера осадок, м", 4},
        {"draft_longitudinal_span_m", "Длина между точками замера осадок, м", 4},
        {"initial_heel_deg", "Начальный крен Θ₀ для гидростатики со знаком, °", 4},
        {"trim_deg", "Угол дифферента ψ со знаком, °", 4},
        {"measurement_mode", "Способ измерения (электронные посты / ручные вески)", 5},
        {"weighing_method", "Способ взвешивания крен-балласта", 5},
        {"transfer_method", "Способ измерения плеч переноса", 5},
        {"observer_direction", "Направление наблюдения и знаки отсчётов", 5},
        {"pendulum_wire_mm", "Диаметр проволоки ручных весков, мм", 5},
        {"rolling_method", "Способ раскачивания и замера периода бортовой качки", 5},
        {"rolling_mass_t", "Масса раскачивающего груза, т", 5},
        {"hydro_source",
         "Источник гидростатики, версия и расчётное состояние (без автозаявления "
         "об одобрении)",
         6},
        {"hydro_volume_m3", "Объёмное водоизмещение V, м³", 6},
        {"hydro_xc_m", "Абсцисса центра величины x_cψ, м", 6},
        {"hydro_zc_m", "Аппликата центра величины z_cψ, м", 6},
        {"hydro_r_m", "Поперечный метацентрический радиус r_ψ, м", 6},
        {"hydro_R_long_m", "Продольный метацентрический радиус R_ψ, м", 6},
        {"center_mode", "Способ определения ЦТ", 6},
        {"center_source", "Документ/метод определения ЦТ и согласование осей и знаков", 6},
        {"hydro_x_sign", "Знак перед (r−h)·sin ψ в Xg: + или − (по согласованной системе осей)", 6},
        {"center_x_m", "ЦТ судна при опыте Xg (ручной ввод), м", 6},
        {"center_y_m", "ЦТ судна при опыте Yg (ручной ввод), м", 6},
        {"center_z_m", "ЦТ судна при опыте Zg (ручной ввод), м", 6},
        {"excess_inventory_complete", "Опись излишних грузов", 6},
        {"missing_inventory_complete", "Опись недостающих грузов", 6},
        {"quality_basis", "Основание оценки качества, редакция правил и соответствие пунктов", 7},
        {"quality_comment", "Пояснения по отбраковке и качеству опыта", 7},
        {"reference_document", "Документ для сравнения характеристик порожнем", 8},
        {"reference_mass_t", "Водоизмещение порожнем по документу, т", 8},
        {"reference_x_m", "Абсцисса ЦТ по документу, м", 8},
        {"reference_z_m", "Аппликата ЦТ по документу, м", 8},
        {"reference_h_m", "Метацентрическая высота по документу, м", 8},
        {"conclusion",
         "Заключение ответственного исполнителя (не автозаявление о "
         "соответствии)",
         8},
        {"required_changes", "Необходимость корректировки судовой документации и основание", 8},
        {"act_a_date", "Акт №1: дата", 10},
        {"act_a_method", "Акт №1: уровень замера, погибь палубы и поправки", 10},
        {"act_a_members", "Акт №1: члены комиссии", 10},
        {"act_b_date", "Акт №2: дата", 11},
        {"act_b_statement", "Акт №2: фактические сведения о недостающих грузах", 11},
        {"act_b_members", "Акт №2: члены комиссии", 11},
        {"act_c_date", "Акт №3: дата", 12},
        {"act_c_statement", "Акт №3: результаты осмотра цистерн", 12},
        {"act_c_members", "Акт №3: члены комиссии", 12},
        {"act_d_date", "Акт №4: дата", 13},
        {"act_d_statement", "Акт №4: результаты осмотра излишних грузов", 13},
        {"act_d_members", "Акт №4: члены комиссии", 13},
        {"act_e_date", "Акт №5: дата", 14},
        {"act_e_ready", "Акт №5: готовность и взвешивание балласта", 14},
        {"act_e_members", "Акт №5: члены комиссии", 14},
        {"act_f_date", "Акт №6: дата", 15},
        {"act_f_method", "Акт №6: способ снятия показаний", 15},
        {"act_f_observer_1", "Акт №6: наблюдатель первого веска", 15},
        {"act_f_observer_2", "Акт №6: наблюдатель второго веска", 15},
        {"metrology_notes",
         "Примечания к поверке/калибровке, пригодность на дату опыта (ввод "
         "ответственного)",
         16}};
    return v;
}

inline const std::vector<TableSpec> &TableSpecs()
{
    static const std::vector<TableSpec> v = {
        {"freeboard",
         "Таблица 1 – Расчётные значения высоты надводного борта и осадка",
         4,
         {"№", "Место замера", "ЛБ до, м", "ЛБ после, м", "ПрБ до, м", "ПрБ после, м", "Средний надводный борт, м",
          "Средняя осадка Tср, м"}},
        {"draft_marks",
         "Таблица 2 – Расчётные значения осадок по маркам углубления",
         4,
         {"Район замера", "ЛБ до, м", "ЛБ после, м", "Среднее ЛБ, м", "ПрБ до, м", "ПрБ после, м", "Среднее ПрБ, м",
          "Среднее, м"}},
        {"ballast",
         "Таблица 3 – Расположение крен-балласта",
         5,
         {"№ группы", "Масса, т", "X от миделя, м", "Y от ДП, м", "Z от ОП, м"}},
        {"moves",
         "Таблица 4 – Перемещения крен-балласта",
         5,
         {"Перемещение", "Группа", "ПрБ (положение)", "ДП (положение)", "ЛБ (положение)", "Плечо переноса со знаком, м",
          "Масса группы, т", "ΔM группы, т·м"}},
        {"instruments",
         "Таблица 5 – Длины и расположение весков и электронных постов",
         5,
         {"№ / пост", "Тип прибора", "Длина веска λ, мм", "X, м", "Y, м", "Z, м", "Расположение / установка / знак"}},
        {"readings_1",
         "Таблица 6 – Показания веска №1 (ручной ввод) / электронных постов",
         5,
         {"Пост / весок", "Наклонение (включая 0)", "№ замера", "Вправо / влево", "Отсчёт веска, мм",
          "Среднее отклонение, мм", "Разность отклонений, мм", "Приращение угла, рад", "Электронный угол, °"}},
        {"readings_2",
         "Таблица 7 – Показания веска №2 (ручной ввод) / электронных постов",
         5,
         {"Пост / весок", "Наклонение (включая 0)", "№ замера", "Вправо / влево", "Отсчёт веска, мм",
          "Среднее отклонение, мм", "Разность отклонений, мм", "Приращение угла, рад", "Электронный угол, °"}},
        {"rolling",
         "Таблица 8 – Расчёт периода бортовой качки",
         5,
         {"Прибор / пост", "Раскачивание", "Число полных колебаний", "Суммарное время, с", "Период T=t/n, с",
          "Среднее, с"}},
        {"metacentric",
         "Таблица 9 – Определение метацентрической высоты при креновании",
         6,
         {"№ измерения / переход", "Δθ постов, рад", "Среднее / выбранное Δθ, рад", "ΔM, т·м", "h_i, м", "h_i − h_k, м",
          "(h_i − h_k)², м²", "Учёт / отбраковка"}},
        {"lightship",
         "Таблица 10 – Определение веса и положения центра тяжести судна "
         "порожнем",
         6,
         {"Наименование", "Масса, т", "Xg, м", "Yg, м", "Zg, м", "Mx=m·X, т·м", "My=m·Y, т·м", "Mz=m·Z, т·м"}},
        {"quality",
         "Таблица 11 – Проверка условия 1.5.9.1",
         7,
         {"№ измерения", "h_i, м", "|h_i − h_k|, м", "Предел 2σ, м", "Проверка / отбраковка"}},
        {"comparison",
         "Таблица 12 – Характеристики судна по результатам опыта",
         8,
         {"Характеристика судна", "По результатам опыта", "По документу", "Отклонение по величине", "Отклонение, %",
          "Примечание"}},
        {"documents",
         "Перечень документации",
         9,
         {"№", "Документ / наименование", "Обозначение", "Редакция / дата", "Источник / наличие"}},
        {"act_freeboard",
         "Акт №1. Таблица 1 – Высота надводного борта",
         10,
         {"Район замера", "ЛБ до, м", "ЛБ после, м", "Среднее ЛБ, м", "ПрБ до, м", "ПрБ после, м", "Среднее ПрБ, м"}},
        {"act_drafts",
         "Акт №1. Таблица 2 – Марки углубления",
         10,
         {"Район замера", "ЛБ до, м", "ЛБ после, м", "Среднее ЛБ, м", "ПрБ до, м", "ПрБ после, м", "Среднее ПрБ, м"}},
        {"missing_loads",
         "Акт №2 – Недостающие грузы",
         11,
         {"Наименование груза", "Положение груза", "Масса, т", "X от М-Ш, м", "Y от ДП, м", "Z от ОП, м",
          "Вес, кН (справочно, не суммируется с массой)"}},
        {"tanks",
         "Акт №3 – Состояние цистерн и жидких грузов судна",
         12,
         {"Наименование цистерны", "Масса, т", "X, м", "Y, м", "Z, м", "Mx, т·м", "My, т·м", "Mz, т·м",
          "Состояние / принадлежность к излишним"}},
        {"excess_loads",
         "Акт №4 – Излишние грузы",
         13,
         {"Наименование", "Положение груза", "Масса, т", "X, м", "Y, м", "Z, м", "Mx, т·м", "My, т·м", "Mz, т·м"}},
        {"act_ballast",
         "Акт №5. Таблица 1 – Расположение крен-балласта",
         14,
         {"№ группы", "Масса, т", "X от миделя, м", "Y от ДП, м", "Z от ОП, м"}},
        {"act_moves",
         "Акт №5. Таблица 2 – Перемещение крен-балласта",
         14,
         {"Перемещение", "Группа", "ПрБ (положение)", "ДП (положение)", "ЛБ (положение)", "Плечо переноса со знаком, м",
          "Масса группы, т", "ΔM группы, т·м"}},
        {"act_readings_1",
         "Акт №6 – Запись показаний первого веска / электронных постов",
         15,
         {"Пост / весок", "Наклонение (включая 0)", "№ замера", "Вправо / влево", "Отсчёт веска, мм",
          "Среднее отклонение, мм", "Разность отклонений, мм", "Приращение угла, рад", "Электронный угол, °"}},
        {"act_readings_2",
         "Акт №6 – Запись показаний второго веска / электронного поста",
         15,
         {"Пост / весок", "Наклонение (включая 0)", "№ замера", "Вправо / влево", "Отсчёт веска, мм",
          "Среднее отклонение, мм", "Разность отклонений, мм", "Приращение угла, рад", "Электронный угол, °"}},
        {"metrology",
         "Сведения о поверке и калибровке средств измерений",
         16,
         {"Прибор / назначение", "Тип / заводской номер", "Номер документа", "Организация", "Дата", "Действителен до",
          "Диапазон / погрешность", "Статус / файл"}},
        {"metrology_details",
         "Метрологические документы – реквизиты лицевой части и оборота",
         16,
         {"Документ / часть", "Обязательный реквизит", "Значение / источник"}},
        {"changes",
         "ЛИСТ РЕГИСТРАЦИИ ИЗМЕНЕНИЙ",
         16,
         {"Изм.", "Изменённых листов", "Заменённых", "Новых", "Аннулированных", "Всего листов", "Номер документа",
          "Входящий номер и дата", "Подпись", "Дата"}}};
    return v;
}

inline Data DefaultData()
{
    Data d;
    for (const auto &f : FieldSpecs())
        d.fields.emplace(f.id, "");
    for (const auto &t : TableSpecs())
        d.tables.emplace(t.id, std::vector<std::vector<std::string>>{});
    // Slots are persistent even when no files are supplied. No source scans or
    // private details.
    d.attachments = {{"organization_logo", "", "Собственный логотип организации для титула (при наличии)"},
                     {"mooring_plan", "", "Рисунок 1 – Схема швартовки судна"},
                     {"tape_calibration", "",
                      "Приложение Ж, лист 1 – Сертификат калибровки рулетки и метрологические "
                      "характеристики"},
                     {"tape_calibration_back", "",
                      "Приложение Ж, лист 1, оборот – Метрологические характеристики и "
                      "результаты измерений рулетки"},
                     {"scales_verification", "",
                      "Приложение Ж, лист 2 – Сведения о результатах поверки весов и средства "
                      "поверки"},
                     {"scales_verification_back", "",
                      "Приложение Ж, лист 2, продолжение – Эталоны, вспомогательные средства "
                      "поверки и дополнительные сведения"},
                     {"hydrometer_passport", "", "Приложение Ж, лист 3 – Паспорт ареометра и характеристики"},
                     {"hydrometer_passport_back", "",
                      "Приложение Ж, лист 3, оборот – Гарантия, приёмка, первичная поверка и "
                      "межповерочный интервал"}};
    return d;
}

namespace model_detail
{
inline std::string Quote(const std::string &s)
{
    std::string out = "\"";
    const char *hex = "0123456789abcdef";
    for (unsigned char c : s)
        switch (c)
        {
        case '"':
            out += "\\\"";
            break;
        case '\\':
            out += "\\\\";
            break;
        case '\n':
            out += "\\n";
            break;
        case '\r':
            out += "\\r";
            break;
        case '\t':
            out += "\\t";
            break;
        default:
            if (c < 32)
            {
                out += "\\u00";
                out += hex[c >> 4];
                out += hex[c & 15];
            }
            else
                out += char(c);
        }
    return out + "\"";
}
inline bool FiniteTree(const json::Value &v)
{
    if (v.IsNumber() && !std::isfinite(v.n))
        return false;
    for (const auto &e : v.arr)
        if (!FiniteTree(e))
            return false;
    for (const auto &e : v.obj)
        if (!FiniteTree(e.second))
            return false;
    return true;
}
} // namespace model_detail

inline std::string ToJson(const Data &d)
{
    using model_detail::Quote;
    std::string out = "{\"fields\":{";
    bool comma = false;
    for (const auto &f : d.fields)
    {
        if (comma)
            out += ',';
        comma = true;
        out += Quote(f.first) + ":" + Quote(f.second);
    }
    out += "},\"tables\":{";
    comma = false;
    for (const auto &t : d.tables)
    {
        if (comma)
            out += ',';
        comma = true;
        out += Quote(t.first) + ":[";
        bool cr = false;
        for (const auto &row : t.second)
        {
            if (cr)
                out += ',';
            cr = true;
            out += '[';
            bool cc = false;
            for (const auto &c : row)
            {
                if (cc)
                    out += ',';
                cc = true;
                out += Quote(c);
            }
            out += ']';
        }
        out += ']';
    }
    out += "},\"attachments\":[";
    comma = false;
    for (const auto &a : d.attachments)
    {
        if (comma)
            out += ',';
        comma = true;
        out += "{\"slot\":" + Quote(a.slot) + ",\"path\":" + Quote(a.path) + ",\"caption\":" + Quote(a.caption) + "}";
    }
    return out + "]}";
}

inline bool FromJson(const json::Value &v, Data &out, std::string *err)
{
    auto fail = [&](const std::string &s) {
        if (err)
            *err = s;
        return false;
    };
    if (!v.IsObject() || !model_detail::FiniteTree(v))
        return fail("formal: expected object with finite values");
    Data d = DefaultData();
    if (v.Has("fields"))
    {
        if (!v["fields"].IsObject())
            return fail("formal.fields: expected object");
        for (const auto &f : v["fields"].obj)
        {
            if (!f.second.IsString())
                return fail("formal.fields." + f.first + ": expected string");
            d.fields[f.first] = f.second.s;
        }
    }
    if (v.Has("tables"))
    {
        if (!v["tables"].IsObject())
            return fail("formal.tables: expected object");
        for (const auto &t : v["tables"].obj)
        {
            if (!t.second.IsArray())
                return fail("formal.tables." + t.first + ": expected rows");
            auto &rows = d.tables[t.first];
            rows.clear();
            for (const auto &row : t.second.arr)
            {
                if (!row.IsArray())
                    return fail("formal.tables." + t.first + ": expected row array");
                std::vector<std::string> r;
                for (const auto &c : row.arr)
                {
                    if (!c.IsString())
                        return fail("formal table cell: expected string");
                    r.push_back(c.s);
                }
                rows.push_back(std::move(r));
            }
        }
    }
    if (v.Has("attachments"))
    {
        if (!v["attachments"].IsArray())
            return fail("formal.attachments: expected array");
        d.attachments.clear();
        for (const auto &a : v["attachments"].arr)
        {
            if (!a.IsObject() || !a["slot"].IsString() || !a["path"].IsString() || !a["caption"].IsString())
                return fail("formal attachment: expected slot, path, caption strings");
            d.attachments.push_back({a["slot"].s, a["path"].s, a["caption"].s});
        }
    }
    out = std::move(d);
    if (err)
        err->clear();
    return true;
}
} // namespace heel::formal
